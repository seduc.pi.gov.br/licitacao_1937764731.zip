Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 53fb90d9-6b27-454d-baf2-0b4c209443c4, NumberOfSaves: 1486], CoordinateReference [CoordinateBase: Coordenadas compartilhadas]
File name: Cobertura Metalica - CineREX.ifc
Time: 2025-12-05T15:59:03-03:00
Written by: ODA SDAI 24.11
Made in: Autodesk Revit 25.0.2.419 (PTB) - IFC 25.0.2.419

# IfcProject, 0001
LongName: ESCOLA DE CINEMA E AUDIOVISUAL - CINEREX; Phase: PROJETO EXECUTIVO

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 cm

# IfcBuilding, CLÍNICA DE REABILITAÇÃO NOVO CAMINHO
LongName: CLÍNICA DE REABILITAÇÃO NOVO CAMINHO
Pset_BuildingCommon - NumberOfStoreys: 9

# IfcBuildingStorey: Nível:Cabeça de 8 mm (4)
In: CLÍNICA DE REABILITAÇÃO NOVO CAMINHO
Name | LongName | Elevation (cm)
Topo do Pilar | Topo do Pilar | 300
Cintamento | Cintamento | 394.898
Nivel315 | Nivel315 | 709.898
Nivel450 | Nivel450 | 844.898

# IfcBuildingStorey: Nível:Extremidade superior de 8 mm (5)
In: CLÍNICA DE REABILITAÇÃO NOVO CAMINHO
Name | LongName | Elevation (cm)
TERRENO NATURAL | TERRENO NATURAL | 0
Nível +2.12 | Nível +2.12 | 372
FORMA DO SUPERIOR (+3.15) | FORMA DO SUPERIOR (+3.15) | 525
FORMA DA COBERTURA (+4.50) | FORMA DA COBERTURA (+4.50) | 660
Nível +7.12 | Nível +7.12 | 872

# IfcBeam: VIGA U Dobrado:U125x50x4.75 (80)
In: Nível +7.12
Type - PredefinedType: BEAM
Type - Pset_BeamCommon - IsExternal: no; LoadBearing: yes
Material: Aço ASTM A36
Pset_BeamCommon - Reference: U125x50x4.75
Pset_QuantityTakeOff - Reference: U125x50x4.75; sets with these values: 2
Name (VIGA U Dobrado:U125x50x4.75:...) | Span (cm) | Slope (deg) | Group
2675458 | 1373.31 | 0 | Grupo de modelos:Treliça:2680215
2675514 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680215
2675534 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680215
2676814 | 25 | 90 | Grupo de modelos:Treliça:2680215
2676846 | 48.4 | 0 | Grupo de modelos:Treliça:2680215
2676864 | 40.3075 | 90 | Grupo de modelos:Treliça:2680215
2678028 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680215
2678050 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680215
2678084 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680215
2679089 | 104.987 | 90 | Grupo de modelos:Treliça:2680215
2679933 | 25 | 90 | Grupo de modelos:Treliça:2680215
2679934 | 48.4 | 0 | Grupo de modelos:Treliça:2680215
2679935 | 40.3075 | 90 | Grupo de modelos:Treliça:2680215
2679936 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680215
2679937 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680215
2679938 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680215
2680547 | 1373.31 | 0 | Grupo de modelos:Treliça:2680583
2680548 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680583
2680549 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680583
2680550 | 25 | 90 | Grupo de modelos:Treliça:2680583
2680551 | 48.4 | 0 | Grupo de modelos:Treliça:2680583
2680552 | 40.3075 | 90 | Grupo de modelos:Treliça:2680583
2680553 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680583
2680554 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680583
2680555 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680583
2680561 | 104.987 | 90 | Grupo de modelos:Treliça:2680583
2680567 | 25 | 90 | Grupo de modelos:Treliça:2680583
2680568 | 48.4 | 0 | Grupo de modelos:Treliça:2680583
2680569 | 40.3075 | 90 | Grupo de modelos:Treliça:2680583
2680570 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680583
2680571 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680583
2680572 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680583
2680613 | 1373.31 | 0 | Grupo de modelos:Treliça:2680649
2680614 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680649
2680615 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680649
2680616 | 25 | 90 | Grupo de modelos:Treliça:2680649
2680617 | 48.4 | 0 | Grupo de modelos:Treliça:2680649
2680618 | 40.3075 | 90 | Grupo de modelos:Treliça:2680649
2680619 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680649
2680620 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680649
2680621 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680649
2680627 | 104.987 | 90 | Grupo de modelos:Treliça:2680649
2680633 | 25 | 90 | Grupo de modelos:Treliça:2680649
2680634 | 48.4 | 0 | Grupo de modelos:Treliça:2680649
2680635 | 40.3075 | 90 | Grupo de modelos:Treliça:2680649
2680636 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680649
2680637 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680649
2680638 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680649
2680694 | 1373.31 | 0 | Grupo de modelos:Treliça:2680730
2680695 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680730
2680696 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680730
2680697 | 25 | 90 | Grupo de modelos:Treliça:2680730
2680698 | 48.4 | 0 | Grupo de modelos:Treliça:2680730
2680699 | 40.3075 | 90 | Grupo de modelos:Treliça:2680730
2680700 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680730
2680701 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680730
2680702 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680730
2680708 | 104.987 | 90 | Grupo de modelos:Treliça:2680730
2680714 | 25 | 90 | Grupo de modelos:Treliça:2680730
2680715 | 48.4 | 0 | Grupo de modelos:Treliça:2680730
2680716 | 40.3075 | 90 | Grupo de modelos:Treliça:2680730
2680717 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680730
2680718 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680730
2680719 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680730
2680786 | 1373.31 | 0 | Grupo de modelos:Treliça:2680822
2680787 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680822
2680788 | 641.524 | 5.78651 | Grupo de modelos:Treliça:2680822
2680789 | 25 | 90 | Grupo de modelos:Treliça:2680822
2680790 | 48.4 | 0 | Grupo de modelos:Treliça:2680822
2680791 | 40.3075 | 90 | Grupo de modelos:Treliça:2680822
2680792 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680822
2680793 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680822
2680794 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680822
2680800 | 104.987 | 90 | Grupo de modelos:Treliça:2680822
2680806 | 25 | 90 | Grupo de modelos:Treliça:2680822
2680807 | 48.4 | 0 | Grupo de modelos:Treliça:2680822
2680808 | 40.3075 | 90 | Grupo de modelos:Treliça:2680822
2680809 | 53.5 | 26.5651 | Grupo de modelos:Treliça:2680822
2680810 | 69.2486 | 18.2774 | Grupo de modelos:Treliça:2680822
2680811 | 70.3471 | 20.8168 | Grupo de modelos:Treliça:2680822

# IfcBeam: Ângulos iguais em L duplo:L30x3 (100)
In: Nível +7.12
Type - PredefinedType: BEAM; Material: Aço, 45-345
Type - Pset_BeamCommon - IsExternal: no; LoadBearing: yes
Pset_BeamCommon - Reference: L30x3
Pset_QuantityTakeOff - Reference: L30x3; sets with these values: 2
Name (Ângulos iguais em L duplo:L30x3:...) | Slope (deg) | Span (cm) | Group
2678741 | 0 | 46.7 | Grupo de modelos:Treliça:2680215
2678967 | 0 | 58.3 | Grupo de modelos:Treliça:2680215
2678978 | 0 | 70 | Grupo de modelos:Treliça:2680215
2678989 | 0 | 81.6 | Grupo de modelos:Treliça:2680215
2679000 | 0 | 93.3 | Grupo de modelos:Treliça:2680215
2679312 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680215
2679345 | 35.3845 | 141 | Grupo de modelos:Treliça:2680215
2679370 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680215
2679400 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680215
2679480 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680215
2679939 | 0 | 46.7 | Grupo de modelos:Treliça:2680215
2679940 | 0 | 58.3 | Grupo de modelos:Treliça:2680215
2679941 | 0 | 70 | Grupo de modelos:Treliça:2680215
2679942 | 0 | 81.6 | Grupo de modelos:Treliça:2680215
2679943 | 0 | 93.3 | Grupo de modelos:Treliça:2680215
2679944 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680215
2679945 | 35.3845 | 141 | Grupo de modelos:Treliça:2680215
2679946 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680215
2679947 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680215
2679948 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680215
2680556 | 0 | 46.7 | Grupo de modelos:Treliça:2680583
2680557 | 0 | 58.3 | Grupo de modelos:Treliça:2680583
2680558 | 0 | 70 | Grupo de modelos:Treliça:2680583
2680559 | 0 | 81.6 | Grupo de modelos:Treliça:2680583
2680560 | 0 | 93.3 | Grupo de modelos:Treliça:2680583
2680562 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680583
2680563 | 35.3845 | 141 | Grupo de modelos:Treliça:2680583
2680564 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680583
2680565 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680583
2680566 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680583
2680573 | 0 | 46.7 | Grupo de modelos:Treliça:2680583
2680574 | 0 | 58.3 | Grupo de modelos:Treliça:2680583
2680575 | 0 | 70 | Grupo de modelos:Treliça:2680583
2680576 | 0 | 81.6 | Grupo de modelos:Treliça:2680583
2680577 | 0 | 93.3 | Grupo de modelos:Treliça:2680583
2680578 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680583
2680579 | 35.3845 | 141 | Grupo de modelos:Treliça:2680583
2680580 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680583
2680581 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680583
2680582 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680583
2680622 | 0 | 46.7 | Grupo de modelos:Treliça:2680649
2680623 | 0 | 58.3 | Grupo de modelos:Treliça:2680649
2680624 | 0 | 70 | Grupo de modelos:Treliça:2680649
2680625 | 0 | 81.6 | Grupo de modelos:Treliça:2680649
2680626 | 0 | 93.3 | Grupo de modelos:Treliça:2680649
2680628 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680649
2680629 | 35.3845 | 141 | Grupo de modelos:Treliça:2680649
2680630 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680649
2680631 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680649
2680632 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680649
2680639 | 0 | 46.7 | Grupo de modelos:Treliça:2680649
2680640 | 0 | 58.3 | Grupo de modelos:Treliça:2680649
2680641 | 0 | 70 | Grupo de modelos:Treliça:2680649
2680642 | 0 | 81.6 | Grupo de modelos:Treliça:2680649
2680643 | 0 | 93.3 | Grupo de modelos:Treliça:2680649
2680644 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680649
2680645 | 35.3845 | 141 | Grupo de modelos:Treliça:2680649
2680646 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680649
2680647 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680649
2680648 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680649
2680703 | 0 | 46.7 | Grupo de modelos:Treliça:2680730
2680704 | 0 | 58.3 | Grupo de modelos:Treliça:2680730
2680705 | 0 | 70 | Grupo de modelos:Treliça:2680730
2680706 | 0 | 81.6 | Grupo de modelos:Treliça:2680730
2680707 | 0 | 93.3 | Grupo de modelos:Treliça:2680730
2680709 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680730
2680710 | 35.3845 | 141 | Grupo de modelos:Treliça:2680730
2680711 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680730
2680712 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680730
2680713 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680730
2680720 | 0 | 46.7 | Grupo de modelos:Treliça:2680730
2680721 | 0 | 58.3 | Grupo de modelos:Treliça:2680730
2680722 | 0 | 70 | Grupo de modelos:Treliça:2680730
2680723 | 0 | 81.6 | Grupo de modelos:Treliça:2680730
2680724 | 0 | 93.3 | Grupo de modelos:Treliça:2680730
2680725 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680730
2680726 | 35.3845 | 141 | Grupo de modelos:Treliça:2680730
2680727 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680730
2680728 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680730
2680729 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680730
2680795 | 0 | 46.7 | Grupo de modelos:Treliça:2680822
2680796 | 0 | 58.3 | Grupo de modelos:Treliça:2680822
2680797 | 0 | 70 | Grupo de modelos:Treliça:2680822
2680798 | 0 | 81.6 | Grupo de modelos:Treliça:2680822
2680799 | 0 | 93.3 | Grupo de modelos:Treliça:2680822
2680801 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680822
2680802 | 35.3845 | 141 | Grupo de modelos:Treliça:2680822
2680803 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680822
2680804 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680822
2680805 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680822
2680812 | 0 | 46.7 | Grupo de modelos:Treliça:2680822
2680813 | 0 | 58.3 | Grupo de modelos:Treliça:2680822
2680814 | 0 | 70 | Grupo de modelos:Treliça:2680822
2680815 | 0 | 81.6 | Grupo de modelos:Treliça:2680822
2680816 | 0 | 93.3 | Grupo de modelos:Treliça:2680822
2680817 | 39.0626 | 148.1 | Grupo de modelos:Treliça:2680822
2680818 | 35.3845 | 141 | Grupo de modelos:Treliça:2680822
2680819 | 31.3379 | 134.6 | Grupo de modelos:Treliça:2680822
2680820 | 26.9114 | 128.9 | Grupo de modelos:Treliça:2680822
2680821 | 22.109 | 124.1 | Grupo de modelos:Treliça:2680822

# IfcBuildingElementProxy: 09-base-com-chumbadores-060523:09-base-com-chumbadores-060523 (10)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 09-base-com-chumbadores-060523; sets with these values: 2
Name (09-base-com-chumbadores-060523:09-base-com-chumbadores-060523:...) | In
2682593 | TERRENO NATURAL
2683444 | Nível +7.12
2683463 | Nível +7.12
2683482 | Nível +7.12
2683539 | Nível +7.12
2683991 | Nível +7.12
2684005 | Nível +7.12
2684019 | Nível +7.12
2684032 | Nível +7.12
2684045 | Nível +7.12

# IfcBuildingElementProxy: Chumbador:Chumbador (60)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Chumbador; sets with these values: 2
Name (Chumbador:Chumbador:...) | In
2682597 | TERRENO NATURAL
2682598 | TERRENO NATURAL
2682607 | TERRENO NATURAL
2682608 | TERRENO NATURAL
2682609 | TERRENO NATURAL
2682610 | TERRENO NATURAL
2683445 | Nível +7.12
2683446 | Nível +7.12
2683453 | Nível +7.12
2683454 | Nível +7.12
2683455 | Nível +7.12
2683456 | Nível +7.12
2683464 | Nível +7.12
2683465 | Nível +7.12
2683472 | Nível +7.12
2683473 | Nível +7.12
2683474 | Nível +7.12
2683475 | Nível +7.12
2683483 | Nível +7.12
2683484 | Nível +7.12
2683491 | Nível +7.12
2683492 | Nível +7.12
2683493 | Nível +7.12
2683494 | Nível +7.12
2683540 | Nível +7.12
2683541 | Nível +7.12
2683548 | Nível +7.12
2683549 | Nível +7.12
2683550 | Nível +7.12
2683551 | Nível +7.12
2683992 | Nível +7.12
2683993 | Nível +7.12
2684000 | Nível +7.12
2684001 | Nível +7.12
2684002 | Nível +7.12
2684003 | Nível +7.12
2684006 | Nível +7.12
2684007 | Nível +7.12
2684014 | Nível +7.12
2684015 | Nível +7.12
2684016 | Nível +7.12
2684017 | Nível +7.12
2684020 | Nível +7.12
2684021 | Nível +7.12
2684028 | Nível +7.12
2684029 | Nível +7.12
2684030 | Nível +7.12
2684031 | Nível +7.12
2684033 | Nível +7.12
2684034 | Nível +7.12
2684041 | Nível +7.12
2684042 | Nível +7.12
2684043 | Nível +7.12
2684044 | Nível +7.12
2684046 | Nível +7.12
2684047 | Nível +7.12
2684054 | Nível +7.12
2684055 | Nível +7.12
2684056 | Nível +7.12
2684057 | Nível +7.12

# IfcBuildingElementProxy: Perfil Ue 100x50x17x1:Perfil Ue 100x50x17x3, Perfil Ue 100x50x17x1:Perfil Ue 100x50x17x3:2687111
In: Nível +7.12
Type - Material: Aço ASTM A36 - Vermelho
Pset_BuildingElementProxyCommon - Reference: Perfil Ue 100x50x17x3; sets with these values: 2

# IfcBuildingElementProxy: Perfil Ue 100x50x17x3:Perfil Ue 100x50x17x3, Perfil Ue 100x50x17x3:Perfil Ue 100x50x17x3:2687040
In: Nível +7.12
Type - Material: Aço ASTM A36 - Vermelho
Pset_BuildingElementProxyCommon - Reference: Perfil Ue 100x50x17x3; sets with these values: 2

# IfcBuildingElementProxy: Porca:Porca (60)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Porca; sets with these values: 2
Name (Porca:Porca:...) | In
2682599 | TERRENO NATURAL
2682600 | TERRENO NATURAL
2682601 | TERRENO NATURAL
2682603 | TERRENO NATURAL
2682604 | TERRENO NATURAL
2682605 | TERRENO NATURAL
2683447 | Nível +7.12
2683448 | Nível +7.12
2683449 | Nível +7.12
2683450 | Nível +7.12
2683451 | Nível +7.12
2683452 | Nível +7.12
2683466 | Nível +7.12
2683467 | Nível +7.12
2683468 | Nível +7.12
2683469 | Nível +7.12
2683470 | Nível +7.12
2683471 | Nível +7.12
2683485 | Nível +7.12
2683486 | Nível +7.12
2683487 | Nível +7.12
2683488 | Nível +7.12
2683489 | Nível +7.12
2683490 | Nível +7.12
2683542 | Nível +7.12
2683543 | Nível +7.12
2683544 | Nível +7.12
2683545 | Nível +7.12
2683546 | Nível +7.12
2683547 | Nível +7.12
2683994 | Nível +7.12
2683995 | Nível +7.12
2683996 | Nível +7.12
2683997 | Nível +7.12
2683998 | Nível +7.12
2683999 | Nível +7.12
2684008 | Nível +7.12
2684009 | Nível +7.12
2684010 | Nível +7.12
2684011 | Nível +7.12
2684012 | Nível +7.12
2684013 | Nível +7.12
2684022 | Nível +7.12
2684023 | Nível +7.12
2684024 | Nível +7.12
2684025 | Nível +7.12
2684026 | Nível +7.12
2684027 | Nível +7.12
2684035 | Nível +7.12
2684036 | Nível +7.12
2684037 | Nível +7.12
2684038 | Nível +7.12
2684039 | Nível +7.12
2684040 | Nível +7.12
2684048 | Nível +7.12
2684049 | Nível +7.12
2684050 | Nível +7.12
2684051 | Nível +7.12
2684052 | Nível +7.12
2684053 | Nível +7.12

# IfcMember: Rectangular Mullion:Perfil Ue (12)
In: FORMA DA COBERTURA (+4.50)
Type - PredefinedType: MULLION; Material: .Aço
Type - Pset_MemberCommon - IsExternal: no
Pset_MemberCommon - IsExternal: yes; Reference: Perfil Ue; Span: 2331.83 cm
Pset_QuantityTakeOff - Reference: Perfil Ue
Name (Rectangular Mullion:Perfil Ue:...)
2686206
2686207
2686208
2686209
2686210
2686211
2686212
2686213
2686214
2686215
2686216
2686217

# IfcRoof: Vidraça inclinada:M - Caibros Metálicos, Vidraça inclinada:M - Caibros Metálicos:2685933
In: FORMA DA COBERTURA (+4.50)
Type - Pset_CurtainWallCommon - IsExternal: yes
Pset_QuantityTakeOff - Reference: M - Caibros Metálicos
Pset_RoofCommon - Reference: M - Caibros Metálicos; IsExternal: yes; ProjectedArea: 322.145 m2
